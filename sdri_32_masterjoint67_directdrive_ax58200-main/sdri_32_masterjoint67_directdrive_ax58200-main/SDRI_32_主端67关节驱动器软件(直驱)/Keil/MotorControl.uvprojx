# Keil uVision project MotorControl.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.22
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: AX58200_MotorControl +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: .\GenEfw.exe  AX58200_MotorControl
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\Library\StdDriver\inc;..\Source;..\For_SSC_Tool\Src;..\Source\McStack;..\Source\TMC4671;..\Source\Test;..\Source\SpiOption;..\Source\MsgProtocol
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ./: startup_M480.s
  group User
    ../Source/: main.c record.txt
  group Library
    ../../../Library/StdDriver/src/: sys.c clk.c uart.c gpio.c epwm.c timer.c eadc.c dac.c qei.c spi.c ecap.c retarget.c fmc.c spim.c bpwm.c
  group Beckhoff SSC
    ../For_SSC_Tool/Src/: AX58200_MotorControl.c AX58200_Hw.c bootmode.c coeappl.c ecatappl.c ecatcoe.c ecatfoe.c ecatslv.c foeappl.c mailbox.c objdef.c sdoserv.c AX58200_FoeAppl.c
  group McStack
    ../Source/McStack/: mc.c mc_misc.c spdfbk.c curfbk.c pwmdrv.c adc_manager.c hall.c six_steps_pwm.c mc_cfg.h mc_types.h
  group TMC4671
    ../Source/TMC4671/: spi_4671.c task_tmc4671.c TMC4671.c
  group FMC_DATA
    ../Source/: FMC_DATA.c
  group LED
    ../Source/: led.c
    ../Source/Test/: Test.c
  group SpiOption
    ../Source/SpiOption/: SPI_Application.c SPI_Config.c
  group MsgProtocol
    ../Source/MsgProtocol/: StmProtocol.c
software components: CMSIS:CORE 5.1.2
