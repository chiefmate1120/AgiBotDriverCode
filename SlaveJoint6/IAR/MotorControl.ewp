# IAR project MotorControl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M480AE series (M481AE,M482AE,M483AE,M484AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\Library\Device\Nuvoton\M480\Include; ..\..\..\Library\CMSIS\Include; ..\..\..\Library\StdDriver\inc; ..\Source; ..\For_SSC_Tool\Src; ..\Source\McStack
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AX58200_MotorControl.bin
  ILINK.IlinkOutputFile: MotorControl.out
  ILINK.IlinkIcfFile: generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group Project/Beckhoff SSC
    ../For_SSC_Tool/Src/: AX58200_Hw.c AX58200_MotorControl.c bootmode.c coeappl.c ecatappl.c ecatcoe.c ecatfoe.c ecatslv.c foeappl.c mailbox.c objdef.c sdoserv.c
  group Project/CMSIS
    ./: startup_M480.s
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group Project/Library
    ../../../Library/StdDriver/src/: clk.c dac.c eadc.c ecap.c epwm.c fmc.c gpio.c qei.c retarget.c spi.c spim.c sys.c timer.c uart.c
  group Project/McStack
    ../Source/McStack/: adc_manager.c curfbk.c hall.c mc.c mc_cfg.h mc_misc.c mc_types.h pwmdrv.c six_steps_pwm.c spdfbk.c
  group Project/User
    ../Source/: main.c
